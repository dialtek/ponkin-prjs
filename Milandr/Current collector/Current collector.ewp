# IAR project Current collector.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x Milandr 1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: D:\work\Projects\Milandr\Current collector\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Current collector.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: Current collector.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Source
    ./: main.c
  group Source/CMSIS
    CMSIS/: core_cm3.c system_MDR32F9Qx.c
  group Source/inc
    inc/: core_cm3.h MDR32Fx.h system_MDR32F9Qx.h
  group Source/Startup
    startup/: startup_MDR32F9Qx.s
