# IAR project Backup of prj_file.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x Milandr 1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: E:\дими\Prj\DDC316_test\DDC316_test\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: prj_file.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Program Files (x86)\IAR Systems\Embedded Workbench 7.0\arm\config\linker\Milandr\MDR1986VE9x\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group src
    ./: main.c
  group src/CMSIS
    CMSIS/: core_cm3.c system_MDR32F9Qx.c
  group src/inc
    inc/: core_cm3.h MDR32Fx.h mdr_delay.h mdr_spi.h MT_12864B_abc.h system_MDR32F9Qx.h
  group src/Startup
    startup/: startup_MDR32F9Qx.s
