# Keil uVision project Demo_Project_1-1.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: 1986VE92 Milandr
  pack: Keil.Milandr_1986VE9x.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo_Project_1-1 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c main.h
software components: Device:Startup 1.0
