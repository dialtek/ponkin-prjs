# Keil uVision project ADC_for_Ports.uvprojx, settings and files
target Source (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC_for_Ports +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc;.\src\h;.\src\c
  asm include: .\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group include
    ./: main.c
  group libs
    ./src/c/: milkites_delay.c milkites_display.c milkites_i2c.c milkites_spi.c milkites_adc.c tlv493d.c pwm_step_motor.c
software components: Device:Startup 1.5, Drivers:PORT 1.5
