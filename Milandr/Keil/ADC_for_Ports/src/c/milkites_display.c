// v2.2

#include "MDR32Fx.h" 
#include "milkites_display.h"
#include "milkites_spi.h" 
#include "milkites_delay.h" 

/*--------------------------------------------------------------------------- */
// -- LCD commands
void LCD_wr_cmd (uint8_t cmd){

LCD_A0_OFF;
SPI1_Wr_Data(cmd);
LCD_A0_ON;
}




void LCD_init (void) {
	
MDR_PORTF->OE      = 0xFFFF;          // порт F на выход, модуль SSP1 
MDR_PORTF->FUNC = (2 << 6) |					// режим  пинов 1, 2, 3, 4 порта 
								(2 << 4) |          // - альтернативный, задействован  SSP1
								(2 << 2) |
								(2 << 0);
MDR_PORTF->ANALOG  = 0xFFFF;          // режим потра - цифровой
MDR_PORTF->PWR     = 0xFFFFFFFF;      // максимально быстрый фронт

MDR32_SSP1_init();			
				
LCD_reset_OFF;
delay_ms(1);
LCD_reset_ON;
LCD_A0_OFF;

for(uint8_t i = 0; i<21;i++) 
{
		SPI1_Wr_Data(INIT_LCD_TABLE[i]);
}

}


void LCD_wr_byte (uint8_t data) {

LCD_A0_ON;
SPI1_Wr_Data(data);
LCD_A0_OFF;
}


void LCD_page_set (uint8_t page) {
LCD_A0_OFF;
SPI1_Wr_Data(0xB0 | page);

}


void LCD_column_set (uint8_t column) {

uint8_t i = 0;
LCD_A0_OFF;
i = column & 0x0F;
SPI1_Wr_Data(0x00+i);
SPI1_Wr_Data(0x10+(column >> 4));

}


void LCD_inverse(uint8_t state) {
// отменить инвертирование цвета дисплея
LCD_A0_OFF;
if(state > 1) return;
if(state)			
SPI1_Wr_Data(0xA7);
else SPI1_Wr_Data(0xA6);
}


void LCD_inverse_OFF (void) {
    // инвертирование цвета дисплея
	  
	LCD_A0_OFF;
	


	}
// ------------------------------------ 
void LCD_set_cursor (uint8_t setPoint){

LCD_page_set(setPoint);
LCD_column_set(0);

}


void LCD_clear (void) {
	
for(uint8_t p=0; p<8; p++) {    //Цикл по всем 8-ми страницам индикатора
LCD_page_set(p);                 //Установка текущей страницы для левого кристалла индикатора
LCD_column_set(0);
for(uint8_t c=0; c<130; c++) {   //Цикл вывода данных в левую половину индикатора
	LCD_wr_byte(0x00);     		 //Вывод очередного байта в индикатор
	
}

}
}


void LCD_wr_char (char symbol){
	
	uint8_t char_code; 
	
switch (symbol) {

case '0': char_code = 0; break; 
case '1': char_code = 1; break; 
case '2': char_code = 2; break; 
case '3': char_code = 3; break; 
case '4': char_code = 4; break; 
case '5': char_code = 5; break; 
case '6': char_code = 6; break; 
case '7': char_code = 7; break; 
case '8': char_code = 8; break; 
case '9': char_code = 9; break; 
case 'А': char_code = 10; break; 
case 'а': char_code = 42; break; 
case 'Б': char_code = 11; break; 
case 'б': char_code = 43; break; 
case 'В': char_code = 12; break; 
case 'в': char_code = 44; break; 
case 'Г': char_code = 13; break; 
case 'г': char_code = 45; break; 
case 'Д': char_code = 14; break; 
case 'д': char_code = 46; break; 
case 'Е': char_code = 15; break; 
case 'е': char_code = 47; break; 
case 'Ё': char_code = 15; break; 
case 'ё': char_code = 47; break; 
case 'Ж': char_code = 16; break; 
case 'ж': char_code = 48; break; 
case 'З': char_code = 17; break; 
case 'з': char_code = 49; break; 
case 'И': char_code = 18; break; 
case 'и': char_code = 50; break; 
case 'Й': char_code = 19; break; 
case 'й': char_code = 51; break; 
case 'К': char_code = 20; break; 
case 'к': char_code = 52; break; 
case 'Л': char_code = 21; break; 
case 'л': char_code = 53; break; 
case 'М': char_code = 22; break; 
case 'м': char_code = 54; break; 
case 'Н': char_code = 23; break; 
case 'н': char_code = 55; break; 
case 'О': char_code = 24; break; 
case 'о': char_code = 56; break; 
case 'П': char_code = 25; break; 
case 'п': char_code = 57; break; 
case 'Р': char_code = 26; break; 
case 'р': char_code = 58; break; 
case 'С': char_code = 27; break; 
case 'с': char_code = 59; break; 
case 'Т': char_code = 28; break; 
case 'т': char_code = 60; break; 
case 'У': char_code = 29; break; 
case 'у': char_code = 61; break; 
case 'Ф': char_code = 30; break; 
case 'ф': char_code = 62; break; 
case 'Х': char_code = 31; break; 
case 'х': char_code = 63; break; 
case 'Ц': char_code = 32; break; 
case 'ц': char_code = 64; break; 
case 'Ч': char_code = 33; break; 
case 'ч': char_code = 65; break; 
case 'Ш': char_code = 34; break; 
case 'ш': char_code = 66; break; 
case 'Щ': char_code = 35; break; 
case 'щ': char_code = 67; break; 
case 'Ъ': char_code = 36; break; 
case 'ъ': char_code = 68; break; 
case 'Ы': char_code = 37; break; 
case 'ы': char_code = 69; break; 
case 'Ь': char_code = 38; break; 
case 'ь': char_code = 70; break; 
case 'Э': char_code = 39; break; 
case 'э': char_code = 71; break; 
case 'Ю': char_code = 40; break; 
case 'ю': char_code = 72; break; 
case 'Я': char_code = 41; break; 
case 'я': char_code = 73; break; 

case 'A': char_code = 10; break; 
case 'a': char_code = 42; break; 
case 'B': char_code = 12; break; 
case 'b': char_code = 89; break; 
case 'C': char_code = 27; break; 
case 'c': char_code = 59; break; 
case 'D': char_code = 74; break; 
case 'd': char_code = 90; break; 
case 'E': char_code = 15; break; 
case 'e': char_code = 47; break; 
case 'F': char_code = 75; break; 
case 'f': char_code = 91; break; 
case 'G': char_code = 76; break; 
case 'g': char_code = 92; break; 
case 'H': char_code = 23; break; 
case 'h': char_code = 93; break; 
case 'I': char_code = 77; break; 
case 'i': char_code = 94; break; 
case 'J': char_code = 78; break; 
case 'j': char_code = 95; break; 
case 'K': char_code = 20; break; 
case 'k': char_code = 96; break; 
case 'L': char_code = 79; break; 
case 'l': char_code = 97; break; 
case 'M': char_code = 22; break; 
case 'm': char_code = 98; break; 
case 'N': char_code = 80; break; 
case 'n': char_code = 99; break; 
case 'O': char_code = 24; break; 
case 'o': char_code = 56; break; 
case 'P': char_code = 26; break; 
case 'p': char_code = 58; break; 
case 'Q': char_code = 81; break; 
case 'q': char_code = 100; break; 
case 'R': char_code = 82; break; 
case 'r': char_code = 101; break;
case 'S': char_code = 83; break; 
case 's': char_code = 102; break; 
case 'T': char_code = 28; break; 
case 't': char_code = 103; break; 
case 'U': char_code = 84; break; 
case 'u': char_code = 104; break; 
case 'V': char_code = 85; break; 
case 'v': char_code = 105; break; 
case 'W': char_code = 86; break; 
case 'w': char_code = 106; break; 
case 'X': char_code = 31; break; 
case 'x': char_code = 63; break; 
case 'Y': char_code = 87; break; 
case 'y': char_code = 107; break; 
case 'Z': char_code = 88; break; 
case 'z': char_code = 108; break; 

case ' ': char_code = 109; break; 
case '+': char_code = 110; break; 
case '-': char_code = 111; break; 
case '=': char_code = 112; break; 
case ':': char_code = 113; break; 
case ',': char_code = 114; break; 
case '.': char_code = 115; break; 
case '?': char_code = 116; break; 
case '#': char_code = 117; break; 
case '!': char_code = 118; break; 
case '"': char_code = 119; break; 
case '$': char_code = 120; break; 
case '%': char_code = 121; break; 
case '&': char_code = 122; break; 
case '(': char_code = 123; break; 
case ')': char_code = 124; break; 
case '*': char_code = 125; break; 
case '/': char_code = 126; break; 
case ';': char_code = 127; break; 
case '<': char_code = 128; break; 
case '>': char_code = 129; break; 
case '@': char_code = 130; break; 
case '[': char_code = 131; break; 
//case '\': char_code = 132; break; 
case ']': char_code = 133; break; 
case '^': char_code = 134; break; 
case '_': char_code = 135; break; 
//case ''': char_code = 136; break; 
case '{': char_code = 137; break; 
case '|': char_code = 138; break; 
case '}': char_code = 139; break; 
case '~': char_code = 140; break; 
// case '°': char_code = ; break;
}

for (uint8_t i=0;i<5;i++)
{ // вывод построчно 	
LCD_wr_byte(LCD_5x7_font[char_code][i]);
}


}


void LCD_print_uni_logo (void) {
// Вывод на дисплей Лого универа и кафедры
	uint8_t logo [8][128] = { 

0xFF, 0x01, 0xFD, 0xFD, 0xFD, 0xE1, 0xE1, 0xF1, 0x39, 0x1D, 0x0D, 0x05, 0x01, 0x01, 0x01, 0xFD, 0xFD, 0xFD, 0x01, 0x81, 0xC1, 0xE1, 0x71, 0x39, 0xFD, 0xFD, 0xFD, 0x01, 0x09, 0x0D, 0x05, 0x05, 0x05, 0xFD, 0xFD, 0xFD, 0x05, 0x05, 0x05, 0x0D, 0x09, 0x05, 0x85, 0x85, 0x85, 0x85, 0x85, 0x85, 0x85, 0xFD, 0xFD, 0xF9, 0x01, 0x01, 0xF9, 0xFD, 0xFD, 0x05, 0x05, 0x05, 0x05, 0x05, 0x05, 0x05, 0x05, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0xC1, 0xE1, 0xE1, 0xF1, 0xF9, 0xFD, 0xFD, 0xFF, 0xDF, 0xBF, 0x7F, 0x7F, 0xFF, 0x8F, 0x8F, 0xFF, 0x7F, 0x7F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3F, 0x9F, 0xDF, 0xDF, 0xDF, 0xDF, 0x3F, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 
0xFF, 0x00, 0x0F, 0x0F, 0x0F, 0x00, 0x01, 0x03, 0x07, 0x0E, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x07, 0x03, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0F, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x0F, 0x0F, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x80, 0xC0, 0xE0, 0xF8, 0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF3, 0x73, 0x9E, 0xA1, 0xC0, 0x40, 0x40, 0xC0, 0xA1, 0x9E, 0x73, 0xF3, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xE0, 0x92, 0x13, 0xE7, 0xEF, 0xE7, 0xC7, 0xCF, 0xDF, 0x0E, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 
0xFF, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0x3C, 0x0E, 0x06, 0x1C, 0x78, 0xE0, 0x80, 0x00, 0x00, 0x1E, 0x3E, 0x20, 0x20, 0x20, 0x20, 0x20, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x22, 0x22, 0x22, 0x22, 0xE2, 0xC2, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x20, 0x20, 0x20, 0x20, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x80, 0xE0, 0xF8, 0x9E, 0x86, 0x9E, 0xB8, 0xE0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0xE0, 0xF8, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xCF, 0x81, 0x9C, 0x9F, 0x3E, 0x7E, 0x1C, 0x19, 0x3B, 0x73, 0x07, 0x4E, 0x1C, 0x00, 0xE0, 0x3C, 0x05, 0xF0, 0xFC, 0xFC, 0x78, 0x01, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 
0xFF, 0xE0, 0xE0, 0xE1, 0xE1, 0x81, 0x81, 0x81, 0x81, 0x81, 0xF1, 0xF1, 0x31, 0x31, 0x31, 0x30, 0x31, 0x31, 0x31, 0x31, 0x31, 0x31, 0x31, 0x31, 0x30, 0x30, 0x31, 0x31, 0xF1, 0xF1, 0x81, 0x81, 0x81, 0x80, 0x80, 0x80, 0x80, 0x81, 0x81, 0x80, 0x80, 0x80, 0x80, 0x81, 0xE1, 0xE0, 0xE0, 0xE1, 0xE1, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x81, 0x80, 0xC0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x1F, 0x7F, 0xFF, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x1C, 0x38, 0x7A, 0xF2, 0xF6, 0xE6, 0xC6, 0xE4, 0xE6, 0xC7, 0xCB, 0xDC, 0x06, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 
0xFF, 0x07, 0x07, 0x07, 0x07, 0x01, 0x01, 0x01, 0x01, 0x01, 0x0F, 0x0F, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0x0F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x07, 0x07, 0xFF, 0xFF, 0x07, 0x07, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x34, 0x80, 0x3B, 0x63, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xAF, 0x37, 0x3B, 0x19, 0x10, 0x8E, 0x86, 0xC1, 0x47, 0x03, 0x03, 0x81, 0xE0, 0xF2, 0xF3, 0x03, 0x02, 0xF0, 0xF1, 0xE3, 0x83, 0x03, 0x03, 0x03, 0x41, 0x8C, 0x8E, 0x1F, 0x1F, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 
0xFF, 0x00, 0x00, 0xF8, 0xFC, 0x04, 0x04, 0xFC, 0xF8, 0x00, 0x04, 0x04, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x04, 0x04, 0xFC, 0xF8, 0x00, 0x04, 0x04, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x04, 0x04, 0xFC, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x3F, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xF3, 0xF7, 0xE0, 0x40, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF0, 0xE0, 0xC2, 0xC3, 0x07, 0x07, 0x01, 0x80, 0x08, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x08, 0x00, 0x00, 0x01, 0x07, 0x03, 0xC2, 0xC0, 0xE0, 0xF0, 0xE1, 0x83, 0x07, 0x1F, 0x7F, 0xFF, 
0xFF, 0x00, 0x00, 0x00, 0x21, 0x21, 0xE1, 0xE1, 0x00, 0x00, 0xC0, 0xE0, 0x21, 0x21, 0xE0, 0xC0, 0x00, 0x21, 0x21, 0xE1, 0xE1, 0x00, 0x00, 0xC0, 0xE0, 0x21, 0x21, 0xE0, 0xC0, 0x20, 0x21, 0xE1, 0xE1, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0xFE, 0xFE, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x40, 0x7E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x01, 0x00, 0x70, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x70, 0x00, 0x00, 0x01, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x40, 0x00, 0xFF, 
0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x8F, 0x8F, 0x80, 0x80, 0x87, 0x8F, 0x88, 0x88, 0x8F, 0x87, 0x80, 0x80, 0x80, 0x8F, 0x8F, 0x80, 0x80, 0x87, 0x8F, 0x88, 0x88, 0x8F, 0x87, 0x80, 0x80, 0x8F, 0x8F, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x86, 0x86, 0x86, 0x86, 0x86, 0x86, 0x87, 0x87, 0x86, 0x86, 0x86, 0x86, 0x86, 0x86, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x87, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x80, 0xF8, 0xF8, 0xF2, 0xF2, 0xE6, 0xE6, 0xEE, 0x80, 0x80, 0x8E, 0xDE, 0xDE, 0xDE, 0xDE, 0x9E, 0x9E, 0x9E, 0xBE, 0x80, 0x80, 0x9E, 0xBE, 0x9E, 0x9E, 0x9E, 0xDE, 0xDE, 0xDE, 0x8E, 0x80, 0x80, 0x80, 0xEE, 0xE6, 0xE6, 0xF2, 0xF2, 0xF8, 0x80, 0x80, 0xFF, 
};

	for(uint8_t p=0; p<8; p++) {
		LCD_page_set(p);
		LCD_column_set(0);
	for(uint8_t i=0; i<128; i++) {
		LCD_wr_byte(logo[p][i]);
	}
}
}
// -------------------------------------	
void LCD_print_num (int32_t number) {

unsigned char buf[10], count = 0;

if (number < 0) // negative num
{
number = -number;
LCD_wr_char('-');
LCD_wr_byte(0); // space 1px
}     
//--
if (number)
{
while(number) // positive num
{ // разложение числа на отдельные цифры
	buf[count++]= number % 10 +'0';
	number /= 10;                 
}                           
while (count)
{ // вывод буфера отдельных чисел на дисплей
	LCD_wr_char(buf[--count]);
	LCD_wr_byte(0); // space 1px
}
}
//--
else LCD_wr_char('0'); // NaN         
}


void LCD_print_text (char* full_str){
	
while (*full_str)
{
	LCD_wr_char(*full_str++);
	LCD_wr_byte(0); // space 1px
}  
}


void Milkites_welcome (void) {

LCD_clear();
LCD_print_uni_logo();
delay_ms(4000);
LCD_clear();
LCD_set_cursor(0);
LCD_print_text("       МилКиТЭС");
LCD_set_cursor(1);
LCD_print_text("==================");
LCD_set_cursor(2);
LCD_print_text("      Отладочная   ");
LCD_set_cursor(4);
LCD_print_text("  плата МК Миландр ");	  
LCD_set_cursor(6);
LCD_print_text("      китэс Дубна ");
//LCD_set_cursor(7);
// LCD_print("      кафедра ПЭ");
delay_ms(5000);

}
