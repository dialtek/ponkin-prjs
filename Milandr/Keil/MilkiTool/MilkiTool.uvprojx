# Keil uVision project MilkiTool.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MilkiTool
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
    ./inc/: milkites_display.h milkites_spi.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.5, Drivers:PORT 1.5
