# Keil uVision project I2C_Project.uvprojx, settings and files
target src (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: I2C_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\libs;..\New_Keil_Pro;.\libs
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ./: main.c
  group milkites_i2c
    ./: i2c_milkites.c
  group tlv493d
    ./: tlv493d.c
  group PWM_Step_Motor
    ./: pwm_step_motor.c
software components: Device:Startup 1.5, Drivers:PORT 1.5
