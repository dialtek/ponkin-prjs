# Keil uVision project PWM_for_ports_PB.uvprojx, settings and files
target Source (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM_for_ports_PB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\ALL_Libs
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group include
    ./: main.c
software components: Device:Startup 1.5, Drivers:PORT 1.5
