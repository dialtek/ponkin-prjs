# Keil uVision project lab_1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab_1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src\c;.\src\h;..\lab_1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
  group libs
    ./src/c/: milkites_adc.c milkites_delay.c milkites_display.c milkites_spi.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5
