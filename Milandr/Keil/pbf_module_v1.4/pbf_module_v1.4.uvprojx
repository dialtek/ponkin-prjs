# Keil uVision project pbf_module_v1.4.uvprojx, settings and files
target src (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1.4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\libs;.\RTOS\include;.\src\h
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ./: main.c
    ./src/h/: main.h
  group RTOS
    ./RTOS/: heap_2.c list.c port.c queue.c tasks.c
  group user libs
    ./src/c/: mdr_uart.c mdr_modbus.c mdr_adc.c
    ./src/h/: mdr_uart.h mdr_modbus.h mdr_adc.h
software components: Device:Startup 1.5, Drivers:PORT 1.5
