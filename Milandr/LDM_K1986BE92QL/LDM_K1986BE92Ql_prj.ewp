# IAR project LDM_K1986BE92Ql_prj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: E:\work\Projects\Milandr\LDM_K1986BE92QL\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LDM_K1986BE92Ql_prj.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.5\arm\config\linker\Milandr\MDR1986VE9x\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group src
    ./: main.c
  group src/CMSIS
    src/CMSIS/: core_cm3.c system_MDR32F9Qx.c
  group src/inc
    inc/: core_cm3.h LCD_MT12864J.h MDR32F9Qx_board.h MDR32F9Qx_config.h MDR32F9Qx_lib.h MDR32F9Qx_port.h MDR32Fx.h mdr_1_wire.h milkites_delay.h milkites_uart.h mt-12864B.h system_MDR32F9Qx.h
  group src/startup
    src/startup/: startup_MDR32F9Qx.s
