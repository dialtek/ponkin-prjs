<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LDM_K1986BE92Ql_prj.ewp</path>
  </project>
  <batchBuild/>
</workspace>


