<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Milkites_OneWire\MilKiTES_2_test.ewp</path>
  </project>
  <batchBuild/>
</workspace>


