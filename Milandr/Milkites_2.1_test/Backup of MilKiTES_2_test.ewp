# IAR project Backup of MilKiTES_2_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: D:\work\Projects\Milandr\Milkites_OneWire\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MilKiTES_2_test.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: MilKiTES_2_test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/: core_cm3.c system_MDR32F9Qx.c
  group inc
    inc/: core_cm3.h MDR32Fx.h mdr_1_wire.h mdr_delay.h mdr_spi.h MT_12864B_abc.h system_MDR32F9Qx.h
  group Startup
    startup/: startup_MDR32F9Qx.s
