# IAR project MilKiTES_2_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: E:\work\Projects\ponkin\Milandr\Milkites_2.1_test\inc; E:\work\Projects\ponkin\Milandr\Milkites_2.1_test\CMSIS; E:\work\Projects\ponkin\Milandr\Milkites_2.1_test\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MilKiTES_2_test.hex
  ILINK.IlinkOutputFile: MilKiTES_2_test.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR1986VE9x\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/: core_cm3.c system_MDR32F9Qx.c
  group inc
    inc/: core_cm3.h MDR32Fx.h milkites_delay.h milkites_spi.h milkites_uart.h MT_12864B_LCD.h system_MDR32F9Qx.h
  group Startup
    startup/: startup_MDR32F9Qx.s
