<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MilKiTES_2_test.ewp</path>
  </project>
  <batchBuild/>
</workspace>


