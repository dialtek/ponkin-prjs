# IAR project MilKiTES_2_test.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MilKiTES_2_test.hex
  ILINK.IlinkOutputFile: MilKiTES_2_test.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/: core_cm3.c system_MDR32F9Qx.c
  group inc
    inc/: core_cm3.h MDR32Fx.h mdr_delay.h mdr_spi.h MT_12864B_abc.h system_MDR32F9Qx.h
  group Startup
    startup/: startup_MDR32F9Qx.s
