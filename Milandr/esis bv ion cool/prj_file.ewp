# IAR project prj_file.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: E:\work\Projects\ponkin\Milandr\esis bv ion cool\inc\; E:\work\Projects\ponkin\Milandr\esis bv ion cool\CMSIS\; E:\work\Projects\ponkin\Milandr\esis bv ion cool\startup\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bv_ion_cool.hex
  ILINK.IlinkOutputFile: prj_file.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR1986VE9x\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group src
    ./: main.c
  group src/CMSIS
    CMSIS/: core_cm3.c system_MDR32F9Qx.c
  group src/inc
    inc/: core_cm3.h MDR32Fx.h mdr_delay.h milkites_uart.h system_MDR32F9Qx.h
  group src/Startup
    startup/: startup_MDR32F9Qx.s
