# IAR project esis_div_key.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: E:\work\Projects\ponkin\Milandr\esis divider key\CMSIS; E:\work\Projects\ponkin\Milandr\esis divider key\Startup; E:\work\Projects\ponkin\Milandr\esis divider key\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: esis_div_key.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR1986VE9x\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS
    CMSIS/: core_cm3.c system_MDR32F9Qx.c
  group inc
    inc/: core_cm3.h MDR32Fx.h mdr_delay.h mdr_spi.h milkites_uart.h system_MDR32F9Qx.h
    ./: main.c
  group startup
    startup/: startup_MDR32F9Qx.s
