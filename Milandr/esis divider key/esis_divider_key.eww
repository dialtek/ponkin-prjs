<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\esis_div_key.ewp</path>
  </project>
  <batchBuild/>
</workspace>


