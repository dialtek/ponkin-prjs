# Keil uVision project test_1.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Milandr.MDR1986BExx.1.4.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test_1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\config;.\libs
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main group
    ./config/: MDR32F9Qx_board.h
    ./: main.c
  group libs
    ./libs/: milkites_delay.h milkites_spi.h milkites_uart.h MT_12864B_LCD.h
software components: CMSIS:CORE 5.0.0, Device:Startup 1.3.1, Drivers:PORT 1.3.1, Drivers:RST_CLK 1.3.1
