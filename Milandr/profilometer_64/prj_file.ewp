# IAR project prj_file.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: F:\Mega\ponkin-prjs\Milandr\profilometer_64\inc; F:\Mega\ponkin-prjs\Milandr\profilometer_64\CMSIS; F:\Mega\ponkin-prjs\Milandr\profilometer_64\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: profilometer_64.hex
  ILINK.IlinkOutputFile: prj_file.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR1986VE9x\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group src
    ./: main.c
  group src/CMSIS
    CMSIS/: core_cm3.c system_MDR32F9Qx.c
  group src/inc
    inc/: core_cm3.h dialtek_modbus.h MDR32Fx.h mdr_delay.h mdr_spi.h MT_12864B_abc.h system_MDR32F9Qx.h
  group src/Startup
    startup/: startup_MDR32F9Qx.s
