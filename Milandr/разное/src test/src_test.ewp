# IAR project src_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x Milandr 1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: D:\work\Projects\Milandr\src test\src\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: src_test.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src_test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group inc
    src/inc/: core_cm3.h MDR32Fx.h mt-12854B.h system_MDR32F9Qx.h
  group src
    src/: main.c
  group src/CMSIS
    src/CMSIS/: core_cm3.c system_MDR32F9Qx.c
  group startup
    src/startup/: startup_MDR32F9Qx.s
