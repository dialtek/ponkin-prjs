<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\src test\src_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\test2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


