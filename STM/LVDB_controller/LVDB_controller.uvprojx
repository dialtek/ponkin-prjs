# Keil uVision project LVDB_controller.uvprojx, settings and files
target Source (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LVDB_controlled +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX
  c include: .\CMSIS;.\User;.\SPL;.\SPL;.\User\inc;.\User\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libs
    ./User/src/: Config.c UART.c modbus.c SPI.c LVDB_ADC.c
    ./User/: main.c
  group CMSIS
    ./CMSIS/: stm32f4xx.h stm32f4xx_conf.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h system_stm32f4xx.h
  group SPL
    ./SPL/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
software components: CMSIS:CORE 5.1.2, Device:Startup 2.6.2
